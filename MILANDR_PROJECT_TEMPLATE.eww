<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MILANDR_PROJECT_TEMPLATE.ewp</path>
    </project>
    <batchBuild />
</workspace>
